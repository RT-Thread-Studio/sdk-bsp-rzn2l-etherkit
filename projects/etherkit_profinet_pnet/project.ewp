# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G084M04 Renesas R9A07G084M04
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _LWIP_ADD_ON_APP=0; ETHERCAT_SSC_PORT_GMAC_MDIO_SUPPORT=1; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$; src\ethercat\beckhoff\Src; src\ethercat\renesas; src\tcpip\renesas\module; src\tcpip\renesas\module\ether_netif; src\tcpip\renesas\module\lwip_port; src\tcpip\renesas\module\serial_io; src\tcpip\renesas\oss_deps\lwip; src\tcpip\oss\amazon-freertos\libraries\3rdparty\lwip_osal\include; src\tcpip\oss\lwip\src\include; board; rt-thread\components\libc\posix\io\poll; rt-thread\components\drivers\ktime\inc; rt-thread\components\net\sal\include; libraries\HAL_Drivers; rt-thread\libcpu\arm\cortex-r52; packages\p-net-rtt-latest\src; rt-thread\components\net\netdev\include; rt-thread\components\libc\posix\ipc; rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4; rt-thread\components\net\lwip\lwip-2.0.3\src\include; rt-thread\components\libc\compilers\common\extension\fcntl\octal; rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif; packages\p-net-rtt-latest\src\ports\rtthread\pn_dev; rt-thread\components\finsh; rt-thread\components\net\sal\include\dfs_net; libraries\HAL_Drivers\config; rt-thread\components\libc\compilers\common\include; packages\p-net-rtt-latest\src\common; rt-thread\components\drivers\ktime; packages\p-net-rtt-latest\osal\src\rtthread; rt-thread\components\libc\compilers\common\extension; packages\p-net-rtt-latest\src\ports\rtthread\pnal; rt-thread\components\net\sal\include\socket; packages\p-net-rtt-latest\osal\include; rt-thread\components\net\lwip\port; rt-thread\components\net\sal\include\socket\sys_socket; rt-thread\include; packages\p-net-rtt-latest\src\ports\rtthread; rt-thread\components\net\sal\impl; rt-thread\components\libc\posix\io\epoll; rt-thread\components\net\lwip\lwip-2.0.3\src\apps\snmp; rt-thread\components\libc\posix\io\eventfd; board\ports; rt-thread\libcpu\arm\common; packages\p-net-rtt-latest\include; rt-thread\components\dfs\dfs_v1\include; rt-thread\components\dfs\dfs_v1\filesystems\devfs; packages\p-net-rtt-latest\src\device; rt-thread\components\dfs\dfs_v1\filesystems\ramfs; .; rt-thread\components\drivers\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  AARM.AUserIncludes: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: script/fsp_xspi0_boot_SystemRAM.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$; board; rt-thread\components\libc\posix\io\poll; rt-thread\components\drivers\ktime\inc; rt-thread\components\net\sal\include; libraries\HAL_Drivers; rt-thread\libcpu\arm\cortex-r52; packages\p-net-rtt-latest\src; rt-thread\components\net\netdev\include; rt-thread\components\libc\posix\ipc; rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4; rt-thread\components\net\lwip\lwip-2.0.3\src\include; rt-thread\components\libc\compilers\common\extension\fcntl\octal; rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif; packages\p-net-rtt-latest\src\ports\rtthread\pn_dev; rt-thread\components\finsh; rt-thread\components\net\sal\include\dfs_net; libraries\HAL_Drivers\config; rt-thread\components\libc\compilers\common\include; packages\p-net-rtt-latest\src\common; rt-thread\components\drivers\ktime; packages\p-net-rtt-latest\osal\src\rtthread; rt-thread\components\libc\compilers\common\extension; packages\p-net-rtt-latest\src\ports\rtthread\pnal; rt-thread\components\net\sal\include\socket; packages\p-net-rtt-latest\osal\include; rt-thread\components\net\lwip\port; rt-thread\components\net\sal\include\socket\sys_socket; rt-thread\include; packages\p-net-rtt-latest\src\ports\rtthread; rt-thread\components\net\sal\impl; rt-thread\components\libc\posix\io\epoll; rt-thread\components\net\lwip\lwip-2.0.3\src\apps\snmp; rt-thread\components\libc\posix\io\eventfd; board\ports; rt-thread\libcpu\arm\common; packages\p-net-rtt-latest\include; rt-thread\components\dfs\dfs_v1\include; rt-thread\components\dfs\dfs_v1\filesystems\devfs; packages\p-net-rtt-latest\src\device; rt-thread\components\dfs\dfs_v1\filesystems\ramfs; .; rt-thread\components\drivers\include
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    rzn_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_memory_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_memory_cfg.h bsp_pin_cfg.h
    rzn_cfg/fsp_cfg/: r_cmt_cfg.h r_ether_cfg.h r_ether_phy_cfg.h r_ether_selector_cfg.h r_ether_switch_cfg.h r_ioport_cfg.h r_sci_uart_cfg.h rm_ethercat_ssc_port_cfg.h
  group Flex Software/Components
    rzn/board/rzn2l_rsk/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
    rzn/fsp/inc/api/: bsp_api.h r_ether_api.h r_ether_phy_api.h r_ether_selector_api.h r_ether_switch_api.h r_ioport_api.h r_timer_api.h r_transfer_api.h r_uart_api.h rm_ethercat_ssc_port_api.h
    rzn/fsp/src/bsp/mcu/all/: bsp_cache.c bsp_cache.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_reset.c bsp_reset.h bsp_sbrk.c bsp_tfu.h
    rzn/fsp/src/bsp/mcu/all/cr/: bsp_cache_core.c bsp_cache_core.h bsp_delay_core.c bsp_delay_core.h bsp_irq_core.c bsp_irq_core.h
    rzn/fsp/src/bsp/mcu/rzn2l/: bsp_elc.h bsp_feature.h bsp_irq_sense.c bsp_loader_param.c bsp_mcu_info.h bsp_override.h
    rzn/arm/CMSIS_5/CMSIS/Core_R/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cr52.h
    rzn/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    rzn/arm/CMSIS_5/: LICENSE.txt
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R9A07G084.h renesas.h system.h
    rzn/fsp/src/r_cmt/: r_cmt.c
    rzn/fsp/inc/instances/: r_cmt.h r_ether_phy.h r_ether_selector.h r_ethsw.h r_gmac.h r_ioport.h r_sci_uart.h rm_ethercat_ssc_port.h
    rzn/fsp/src/r_ether_phy/: r_ether_phy.c
    rzn/fsp/src/r_ether_selector/: r_ether_selector.c
    rzn/fsp/src/r_ethsw/: r_ethsw.c
    rzn/fsp/src/r_gmac/: r_gmac.c
    rzn/fsp/src/r_ioport/: r_ioport.c
    rzn/fsp/src/r_sci_uart/: r_sci_uart.c
    rzn/fsp/src/rm_ethercat_ssc_port/: renesashw.h rm_ethercat_ssc_port.c
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/cr/: startup_core.c system_core.c
  group Flex Software/Generated Data
    rzn_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c
  group Compiler
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    rt-thread/libcpu/arm/cortex-r52/: interrupt.c cpuport.c context_iar.S trap.c stack.c start_iar.S vector_iar.S backtrace.c gicv3.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    libraries/HAL_Drivers/: drv_common.c drv_eth.c drv_gpio.c drv_usart_v2.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/ramfs/: dfs_ramfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: cmd.c shell.c msh.c msh_parse.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group ktime
    rt-thread/components/drivers/ktime/src/: boottime.c cputimer.c hrtimer.c
  group libcpu
    rt-thread/libcpu/arm/common/: showmem.c div0.c atomic_arm.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/snmp/: snmp_asn1.c snmp_core.c snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_netconn.c snmp_pbuf_stream.c snmp_raw.c snmp_scalar.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_dummy.c snmpv3_mbedtls.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group p-net/common
    packages/p-net-rtt-latest/src/common/: pf_cpm_driver_sw.c pf_file.c pf_ptcp.c pf_bg_worker.c pf_eth.c pf_dcp.c pf_ppm.c pf_cpm.c pf_lldp.c pf_ppm_driver_sw.c pf_alarm.c pf_scheduler.c pf_udp.c
  group p-net/device
    packages/p-net-rtt-latest/src/device/: pf_cmwrr.c pf_cmrpc_helpers.c pf_cmina.c pf_cmrpc_epm.c pnet_api.c pf_block_writer.c pf_cmrpc.c pf_cmpbe.c pf_fspm.c pf_cmdev.c pf_cmrdr.c pf_cmio.c pf_cmdmc.c pf_block_reader.c pf_cmrs.c pf_diag.c pf_port.c pf_cmsu.c pf_cmsm.c pf_plugsm.c pf_pdport.c
  group p-net/osal
    packages/p-net-rtt-latest/osal/src/rtthread/: osal.c osal_log.c
  group p-net/port
    packages/p-net-rtt-latest/osal/src/rtthread/: osal.c osal_log.c
    packages/p-net-rtt-latest/src/ports/rtthread/pnal/: pnal_udp.c pnal.c pnal_eth.c
  group p-net/sample
    packages/p-net-rtt-latest/src/ports/rtthread/pn_dev/: app_data.c app_log.c sampleapp_main.c sampleapp_common.c sampleapp_board.c app_utils.c app_gsdml.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
