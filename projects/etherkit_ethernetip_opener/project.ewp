# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G084M04 Renesas R9A07G084M04
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _LWIP_ADD_ON_APP=0; ETHERCAT_SSC_PORT_GMAC_MDIO_SUPPORT=1; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_; _RZN_ORDINAL=1; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; OPENER_CONSUMED_DATA_HAS_RUN_IDLE_HEADER; RESTRICT=__restrict; OPENER_WITH_TRACES; OPENER_TRACE_LEVEL=3; PC_OPENER_ETHERNET_BUFFER_SIZE=512; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$; src\ethercat\beckhoff\Src; src\ethercat\renesas; src\tcpip\renesas\module; src\tcpip\renesas\module\ether_netif; src\tcpip\renesas\module\lwip_port; src\tcpip\renesas\module\serial_io; src\tcpip\renesas\oss_deps\lwip; src\tcpip\oss\amazon-freertos\libraries\3rdparty\lwip_osal\include; src\tcpip\oss\lwip\src\include; rt-thread\include; rt-thread\components\dfs\dfs_v1\include; packages\OpENer-latest\source\src\enet_encap; rt-thread\components\libc\posix\io\eventfd; src; rt-thread\components\libc\posix\io\poll; packages\OpENer_port-latest\sample_application; rt-thread\components\libc\compilers\common\extension\fcntl\octal; rt-thread\components\libc\compilers\common\extension; rt-thread\components\drivers\ktime; rt-thread\components\net\lwip\lwip-2.0.3\src\apps\snmp; rt-thread\components\finsh; rzn\fsp\inc\instances; rt-thread\libcpu\arm\cortex-r52; rzn\fsp\inc\api; rzn\fsp\inc; rt-thread\components\libc\compilers\common\include; board\ports; .; packages\OpENer-latest\source\src; libraries\HAL_Drivers; rzn\arm\CMSIS_5\CMSIS\Core_R\Include; libraries\HAL_Drivers\config; packages\OpENer-latest\source\src\ports; packages\OpENer_port-latest; packages\OpENer-latest\source\src\utils; rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif; rt-thread\components\net\netdev\include; rt-thread\components\dfs\dfs_v1\filesystems\ramfs; rzn_gen; rt-thread\components\libc\posix\ipc; rt-thread\components\drivers\include; rt-thread\components\net\sal\include\socket; board; rt-thread\components\net\sal\impl; rt-thread\components\net\lwip\lwip-2.0.3\src\include; rzn_cfg\fsp_cfg\bsp; rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4; rt-thread\components\libc\posix\io\epoll; rt-thread\components\drivers\ktime\inc; rt-thread\components\net\lwip\port; rt-thread\components\libc\posix\io\stdio; rt-thread\components\net\sal\include; rzn_cfg\fsp_cfg; rt-thread\libcpu\arm\common; rt-thread\components\net\sal\include\dfs_net; rt-thread\components\dfs\dfs_v1\filesystems\devfs; packages\OpENer-latest\source\src\cip; rt-thread\components\net\sal\include\socket\sys_socket
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  AARM.AUserIncludes: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: script/fsp_xspi0_boot.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_; _RZN_ORDINAL=1; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; OPENER_CONSUMED_DATA_HAS_RUN_IDLE_HEADER; RESTRICT=__restrict; OPENER_WITH_TRACES; OPENER_TRACE_LEVEL=3; PC_OPENER_ETHERNET_BUFFER_SIZE=512; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$; rt-thread\include; rt-thread\components\dfs\dfs_v1\include; packages\OpENer-latest\source\src\enet_encap; rt-thread\components\libc\posix\io\eventfd; src; rt-thread\components\libc\posix\io\poll; packages\OpENer_port-latest\sample_application; rt-thread\components\libc\compilers\common\extension\fcntl\octal; rt-thread\components\libc\compilers\common\extension; rt-thread\components\drivers\ktime; rt-thread\components\net\lwip\lwip-2.0.3\src\apps\snmp; rt-thread\components\finsh; rzn\fsp\inc\instances; rt-thread\libcpu\arm\cortex-r52; rzn\fsp\inc\api; rzn\fsp\inc; rt-thread\components\libc\compilers\common\include; board\ports; .; packages\OpENer-latest\source\src; libraries\HAL_Drivers; rzn\arm\CMSIS_5\CMSIS\Core_R\Include; libraries\HAL_Drivers\config; packages\OpENer-latest\source\src\ports; packages\OpENer_port-latest; packages\OpENer-latest\source\src\utils; rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif; rt-thread\components\net\netdev\include; rt-thread\components\dfs\dfs_v1\filesystems\ramfs; rzn_gen; rt-thread\components\libc\posix\ipc; rt-thread\components\drivers\include; rt-thread\components\net\sal\include\socket; board; rt-thread\components\net\sal\impl; rt-thread\components\net\lwip\lwip-2.0.3\src\include; rzn_cfg\fsp_cfg\bsp; rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4; rt-thread\components\libc\posix\io\epoll; rt-thread\components\drivers\ktime\inc; rt-thread\components\net\lwip\port; rt-thread\components\libc\posix\io\stdio; rt-thread\components\net\sal\include; rzn_cfg\fsp_cfg; rt-thread\libcpu\arm\common; rt-thread\components\net\sal\include\dfs_net; rt-thread\components\dfs\dfs_v1\filesystems\devfs; packages\OpENer-latest\source\src\cip; rt-thread\components\net\sal\include\socket\sys_socket
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
  group Applications
    src/: hal_entry.c
  group Compiler
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    rt-thread/libcpu/arm/cortex-r52/: gicv3.c trap.c vector_iar.S cpuport.c start_iar.S interrupt.c backtrace.c context_iar.S stack.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    libraries/HAL_Drivers/: drv_common.c drv_eth.c drv_gpio.c drv_usart_v2.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/ramfs/: dfs_ramfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group ktime
    rt-thread/components/drivers/ktime/src/: hrtimer.c boottime.c cputimer.c
  group libcpu
    rt-thread/libcpu/arm/common/: showmem.c div0.c atomic_arm.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/snmp/: snmp_asn1.c snmp_core.c snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_netconn.c snmp_pbuf_stream.c snmp_raw.c snmp_scalar.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_dummy.c snmpv3_mbedtls.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group OpENer/port
    packages/OpENer_port-latest/: opener_error.c opener.c networkconfig.c networkhandler.c
    packages/OpENer_port-latest/sample_application/: ethlinkcbs.c sampleapplication.c
  group OpENer/src
    packages/OpENer-latest/source/src/cip/: cipdlr.c cipioconnection.c cipconnectionmanager.c cipconnectionobject.c cipepath.c cipstringi.c cipelectronickey.c cipstring.c cipqos.c cipethernetlink.c cipassembly.c cipidentity.c cipcommon.c cipclass3connection.c ciptypes.c ciptcpipinterface.c cipmessagerouter.c appcontype.c
    packages/OpENer-latest/source/src/enet_encap/: endianconv.c cpf.c encap.c
    packages/OpENer-latest/source/src/utils/: doublylinkedlist.c enipmessage.c xorshiftrandom.c random.c
    packages/OpENer-latest/source/src/ports/: socket_timer.c generic_networkhandler.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
    rt-thread/components/libc/posix/io/stdio/: stdio.c
  group RZN
    rzn/fsp/src/bsp/mcu/all/: bsp_tzc400.c bsp_semaphore.c bsp_clocks.c bsp_reset.c bsp_ddr.c bsp_irq.c bsp_common.c bsp_io.c bsp_slave_stop.c bsp_sbrk.c bsp_ddr_fw_param.c bsp_delay.c bsp_address_expander.c bsp_register_protection.c bsp_cache.c
    rzn/fsp/src/r_sci_uart/: r_sci_uart.c
    rzn/fsp/src/r_gmac/: r_gmac.c
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/: system.c startup.c
    rzn/fsp/src/r_ioport/: r_ioport.c
    rzn/fsp/src/bsp/mcu/all/cr/: bsp_delay_core.c bsp_cache_core.c bsp_irq_core.c
    rzn/fsp/src/r_ether_selector/: r_ether_selector.c
    rzn/fsp/src/r_ether_phy/: r_ether_phy.c
    rzn/fsp/src/bsp/mcu/rzn2l/: bsp_loader_param.c bsp_irq_sense.c
    rzn/fsp/src/r_ethsw/: r_ethsw.c
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/cr/: startup_core.c system_core.c
  group RZN_gen
    rzn_gen/: main.c common_data.c vector_data.c pin_data.c hal_data.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
