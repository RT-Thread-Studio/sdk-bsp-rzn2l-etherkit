# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G084M04 Renesas R9A07G084M04
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _LWIP_ADD_ON_APP=0; ETHERCAT_SSC_PORT_GMAC_MDIO_SUPPORT=1; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$; src\ethercat\beckhoff\Src; src\ethercat\renesas; src\tcpip\renesas\module; src\tcpip\renesas\module\ether_netif; src\tcpip\renesas\module\lwip_port; src\tcpip\renesas\module\serial_io; src\tcpip\renesas\oss_deps\lwip; src\tcpip\oss\amazon-freertos\libraries\3rdparty\lwip_osal\include; src\tcpip\oss\lwip\src\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  AARM.AUserIncludes: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: script/fsp_xspi0_boot.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
