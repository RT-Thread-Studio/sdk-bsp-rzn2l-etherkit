# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G084M04 Renesas R9A07G084M04
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _LWIP_ADD_ON_APP=0; ETHERCAT_SSC_PORT_GMAC_MDIO_SUPPORT=1; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_; _RZN_ORDINAL=1; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; LFS_CONFIG=lfs_config.h; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$; src\ethercat\beckhoff\Src; src\ethercat\renesas; src\tcpip\renesas\module; src\tcpip\renesas\module\ether_netif; src\tcpip\renesas\module\lwip_port; src\tcpip\renesas\module\serial_io; src\tcpip\renesas\oss_deps\lwip; src\tcpip\oss\amazon-freertos\libraries\3rdparty\lwip_osal\include; src\tcpip\oss\lwip\src\include; rt-thread\libcpu\arm\cortex-r52; rt-thread\components\drivers\include; libraries\HAL_Drivers\config; rt-thread\components\libc\compilers\common\extension\fcntl\octal; rzn\fsp\inc\instances; rt-thread\components\libc\compilers\common\extension; board; libraries\HAL_Drivers; rzn_cfg\fsp_cfg\bsp; rzn_gen; rt-thread\components\libc\posix\io\poll; rzn\fsp\inc\api; src; rzn_cfg\driver; rt-thread\components\finsh; board\ports; rzn\fsp\inc; rt-thread\include; rt-thread\components\libc\posix\io\epoll; rt-thread\components\libc\posix\ipc; rt-thread\components\fal\inc; packages\littlefs-latest; board\ports\filesystem; rt-thread\libcpu\arm\common; rt-thread\components\libc\compilers\common\include; rzn\arm\CMSIS_5\CMSIS\Core_R\Include; .; rt-thread\components\dfs\dfs_v1\include; rt-thread\components\dfs\dfs_v1\filesystems\devfs; rt-thread\components\libc\posix\io\eventfd; rzn_cfg\fsp_cfg
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_
  AARM.AUserIncludes: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: script/fsp_xspi0_boot.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RZN_ORDINAL=1; _RZN_CORE=CR52_0; _RENESAS_RZN_; _RZN_ORDINAL=1; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; LFS_CONFIG=lfs_config.h; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/bsp/mcu/all/cr; rzn/fsp/src/rm_ethercat_ssc_port; rzn/fsp/src/rm_freertos_port/cr; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; $PROJ_DIR$; rt-thread\libcpu\arm\cortex-r52; rt-thread\components\drivers\include; libraries\HAL_Drivers\config; rt-thread\components\libc\compilers\common\extension\fcntl\octal; rzn\fsp\inc\instances; rt-thread\components\libc\compilers\common\extension; board; libraries\HAL_Drivers; rzn_cfg\fsp_cfg\bsp; rzn_gen; rt-thread\components\libc\posix\io\poll; rzn\fsp\inc\api; src; rzn_cfg\driver; rt-thread\components\finsh; board\ports; rzn\fsp\inc; rt-thread\include; rt-thread\components\libc\posix\io\epoll; rt-thread\components\libc\posix\ipc; rt-thread\components\fal\inc; packages\littlefs-latest; board\ports\filesystem; rt-thread\libcpu\arm\common; rt-thread\components\libc\compilers\common\include; rzn\arm\CMSIS_5\CMSIS\Core_R\Include; .; rt-thread\components\dfs\dfs_v1\include; rt-thread\components\dfs\dfs_v1\filesystems\devfs; rt-thread\components\libc\posix\io\eventfd; rzn_cfg\fsp_cfg
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
  group Applications
    src/: hal_entry.c
  group Compiler
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    rt-thread/libcpu/arm/cortex-r52/: start_iar.S gicv3.c vector_iar.S stack.c cpuport.c trap.c backtrace.c context_iar.S interrupt.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
  group Fal
    rt-thread/components/fal/src/: fal_flash.c fal_rtt.c fal.c fal_partition.c
  group filesystem
    board/ports/filesystem/: drv_filesystem.c drv_n2l_flash.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: msh_parse.c shell.c cmd.c msh_file.c msh.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: showmem.c atomic_arm.c div0.c
  group littlefs
    packages/littlefs-latest/: dfs_lfs.c lfs.c lfs_util.c lfs_crc.c
  group RZN
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/: system.c startup.c
    rzn/fsp/src/bsp/mcu/all/: bsp_delay.c bsp_semaphore.c bsp_reset.c bsp_io.c bsp_tzc400.c bsp_slave_stop.c bsp_register_protection.c bsp_address_expander.c bsp_ddr_fw_param.c bsp_sbrk.c bsp_clocks.c bsp_common.c bsp_ddr.c bsp_irq.c bsp_cache.c
    rzn/fsp/src/bsp/mcu/all/cr/: bsp_irq_core.c bsp_delay_core.c bsp_cache_core.c
    rzn/fsp/src/r_xspi_qspi/: r_xspi_qspi.c
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/cr/: startup_core.c system_core.c
    rzn/fsp/src/r_ioport/: r_ioport.c
    rzn/fsp/src/r_sci_uart/: r_sci_uart.c
    rzn/fsp/src/bsp/mcu/rzn2l/: bsp_loader_param.c bsp_irq_sense.c
    rzn/fsp/src/r_xspi_hyper/: r_xspi_hyper.c
  group RZN_gen
    rzn_gen/: vector_data.c common_data.c main.c hal_data.c pin_data.c
